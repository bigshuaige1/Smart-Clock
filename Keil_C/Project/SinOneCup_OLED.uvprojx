# Keil uVision project SinOneCup_OLED.uvprojx, settings and files
target <SinOneCup_OLED> (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SC32F10TS8 SinOneMicroelectronics
  pack: SinOne.SC32F1xxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SinOneCup_OLED +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: SC32f10xx
  c include: ..\FWLib\SC32F1XXX_Lib\inc;..\User\HeadFiles;..\User;..\Drivers;..\Apps;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: ROM 0x20000000 size 0x2000
  group User
    ../User/: main.c system_sc32f1xxx.c SC_it.c SC_Init.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
    ./: shizhong.h shizhong.c
  group FWLib
    ../FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_twi.c sc32f1xxx_option.c sc32f1xxx_rcc.c sc32f1xxx_gpio.c
  group Startup
    ./: startup_sc32f10xx.s
